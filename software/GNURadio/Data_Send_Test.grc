<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>USRP_IP</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>carrier_freq</value></param>
<param><key>gain0</key><value>recieve_gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>recieve_gain</value></param>
<param><key>label</key><value>Recieve Gain (dB)</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>8192</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>value</key><value>915000000</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>send_gain</value></param>
<param><key>label</key><value>Send Gain (dB)</value></param>
<param><key>value</key><value>40</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Plots</value></param>
<param><key>label1</key><value>Settings</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>carrier_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>gui_hint</key><value>cons_tabs@0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>cons_tabs</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Sending</value></param>
<param><key>label1</key><value>Receiving</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>carrier_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>gui_hint</key><value>cons_tabs@1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>USRP_IP</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>carrier_freq</value></param>
<param><key>gain0</key><value>send_gain</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>alpha</key><value>rms_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>update_period</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>USRP_IP</value></param>
<param><key>value</key><value>addr=192.168.10.14</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>send_byte</value></param>
<param><key>label</key><value>Byte_To_Send</value></param>
<param><key>value</key><value>79</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>255</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>low_cutoff_freq</key><value>sub_carrier_freq - (sub_carrier_freq / 10)</value></param>
<param><key>high_cutoff_freq</key><value>sub_carrier_freq + (sub_carrier_freq / 10)</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>sub_carrier_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sub_carrier_freq</value></param>
<param><key>label</key><value>Sub-Carrier Freq (Hz)</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>50000</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>PowerBlade_Utils_ByteToPseudoUARTi</key>
<param><key>id</key><value>PowerBlade_Utils_ByteToPseudoUARTi_0</value></param>
<param><key>timingBit</key><value>1</value></param>
<param><key>rearPadding</key><value>2</value></param>
<param><key>rearPause</key><value>5</value></param>
<param><key>symbolsPerBlock</key><value>0</value></param>
<param><key>blockPause</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interp</key><value>500</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-0.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rms_alpha</value></param>
<param><key>label</key><value>rms_alpha</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>255</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
<param><key>freq</key><value>1</value></param>
<param><key>amp</key><value>255</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>PowerBlade_Utils_ByteToPseudoUARTi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PowerBlade_Utils_ByteToPseudoUARTi_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
